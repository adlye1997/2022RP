# Keil uVision project ME_Empty.uvprojx, settings and files
target ME_Empty (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: ME_Empty +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4
  c include: ../Core/Inc;        ../Drivers/STM32F4xx_HAL_Driver/Inc;        ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;        ../Middlewares/Third_Party/FreeRTOS/Source/include;        ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;        ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;        ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;        ../Drivers/CMSIS/Include;        ..\Application\drive;        ..\Application\potocol;        ..\Application\Algorithm;        ..\Application\device;        ..\Application\hardware;        ..\Application\config;        ..\Application\note;        ..\Application\task;        ..\Application\module;        ..\Application\device\Imu;        ..\Drivers\CMSIS\DSP\Include;        ..\Application\support
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: freertos.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/DSP/Include/: arm_math.h
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group drive
    ../Application/drive/: drive.c drv_can.c drv_uart.c
  group potocol
    ../Application/potocol/: remote_potocol.c vision_potocol.c crc8.c crc16.c judge_potocol.c cap_protocol.c
  group algorithm
    ../Application/Algorithm/: pid.c
  group device
    ../Application/device/: chassis_motor.c gimbal_motor.c launcher_motor.c remote.c imu.c led.c cap.c
    ../Application/support/: my_judge.c
  group hardware
    ../Application/hardware/: 3508_motor.c 6020_motor.c 2006_motor.c
  group config
    ../Application/config/: config.h config_can.c config_uart.c config_pid.c config_tracking_differentiator.c config_usmart.c config_car.h config_chassis.h config_gimbal.h config_launcher.h config_imu.h config_remote.h
  group note
    ../Application/note/: note.c
  group task
    ../Application/task/: task.c
  group module
    ../Application/module/: car.c chassis.c gimbal.c launcher.c vision.c judge.c debug.c
  group imu
    ../Application/device/Imu/: bmi.c bmi2.c bmi2_common.c bmi2_ois.c bmi270.c bmi270_context.c soft_iic.c bmi2_defs.h
    ../Application/drive/: drv_haltick.c
  group support
    ../Application/support/: frequency.c lowpass_observation.c ave_filter.c math_support.c timer.c tracking_differentiator.c pid_feedback_system.c usmart.c
software components: CMSIS:CORE 4.3.0
